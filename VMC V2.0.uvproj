# Keil uVision project VMC V2.0.uvproj, settings and files
target VMC-V2.02 (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: VMC_V2.09_2015_x_x +hex
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  scatter file: .\Firmware\SRAM_SCT.sct
  link misc: --entry __main
  group APP
    ./APP/: MAIN.C BUSINESS.C MAINTAIN.C COMMON.C LANGUAGE.C CHANNEL.C LIFTTABLE.c ACDC.C
  group API
    ./API/: ACDCAPI.c BillAccepterAPI.c CoinAccepterAPI .c TuibiAPI.c CheckDeviceState.c LogAPI.c TraceAPI.c PCComAPI.c LiftTableAPI.c SelectKeyAPI.c ChannelAPI.c ChangerAPI.c ReaderAPI.c ZhiHuiAPI.c GprsAPI.c HeFanGuiAPI.c
  group TASK-DEVICE
    ./Drivers/: TASKDEVICE.C MDB_UART2.C EVB_UART2.C BillAccepter.c CoinAccepter .c MDBReader.c LiftTableDriver.c ACDCDriver.c ChannelDriver.c HopperDriver.c MDBChanger.c
  group TASK-UART3DEVICE
    ./Uart3Driver/: TASKUART3DEVICE.C ZHIHUIPC.c UBProtocol.c VMC_GPRS_PC.c
  group TASK-UART1DEVICE
    ./Uart1Driver/: SelectKey.c TASKUART1DEVICE.C xmt.c HeFanGui.c
  group DRIVERS
    ./Drivers/: UART2.C UART0.C UART1.C UART3.C RTC.C I2C.C LCD.C KEY.C PCOIN.C TIMER.C BUZZER.C AT45DB161D.C GPRS_UART.c
  group uCOS-II
    ./uCOS_II/cpu/: Os_cpu_c.c
    ./uCOS_II/hook/: uCOS-II hook.lib
    ./uCOS_II/: OS_CORE.C OS_FLAG.C OS_MBOX.C OS_MEM.C OS_TIME.C OS_TASK.C OS_SEM.C OS_Q.C OS_MUTEX.C
  group FIRMWARE
    ./Firmware/: LPC1700PinCfg.c target.c vector_table.c zy_if.c
  group STARTUP
    ./Startup/: rt_sys_c.c rt_sys_s.s
  group TASK-UART0DEVICE
    ./Uart0Driver/: taskUart0Device.c
